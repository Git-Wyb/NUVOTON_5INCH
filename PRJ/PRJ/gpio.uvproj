# Keil uVision project gpio.uvproj, settings and files
target gpio (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: 7inch_pro +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: NO_TIMER, IS_FPGA,POWER_INT_MODE,DEBUG,SYSUARTPRINTF
  c include: ..\..\Driver\Include;..\..\Library\UsbHostLib\inc;..\..\ThirdParty\FATFS\source;..\..\ThirdParty\yaffs2\include;..\PRJ
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\Script\nuc970.sct
  link misc: --entry 0
  group src
    ./: DISPLAY.C diskio.c main.c Aprotocol.c BSP_Init.c Command_G.c nand_nand.c Command_D.c Command_Q.c Command_C.c Command_M.c Command_TR.c DIP_SW.c Atime.c Command_P.c Command_B.c Command_I.c Command_W.c Command_Y.c Command_X.c Command_H.c Command_E.c Command_F.C Poweron.c hard_function_test.c poweroff.c biaoyan.c W25Q128.c
  group Libraries
    ../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_nuc970.c startup_NUC970.s sys_nuc970.s gpio.c lcd.c 2d.c usbd.c uart.c rtc.c adc.c pwm.c i2c.c wwdt.c etimer.c spi.c
  group src_fatfs
    ../../ThirdParty/FATFS/source/: ff.c ffsystem.c ffunicode.c
  group src_usb_core
    ../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci.c support.c usb_core.c
  group src_usb_umas
    ../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
